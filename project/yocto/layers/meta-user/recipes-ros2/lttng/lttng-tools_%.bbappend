PACKAGECONFIG:append = " python lttng-ust"
