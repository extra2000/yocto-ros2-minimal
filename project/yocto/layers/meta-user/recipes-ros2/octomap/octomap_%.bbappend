EXTRA_OECMAKE:append = "-DCMAKE_CXX_STANDARD=14"

BBCLASSEXTEND:append = " native nativesdk"
