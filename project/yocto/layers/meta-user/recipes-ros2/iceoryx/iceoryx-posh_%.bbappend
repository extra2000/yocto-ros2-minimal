FILES:${PN} += " \
    ${SDKPATHNATIVE}/usr/etc \
    ${SDKPATHNATIVE}/usr/etc/roudi_config_example.toml \
"
