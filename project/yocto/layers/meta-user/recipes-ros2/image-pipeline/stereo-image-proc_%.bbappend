ROS_BUILD_DEPENDS:append = " \
    python3-numpy \
    python3-numpy-native \
"

ROS_EXEC_DEPENDS:append = " \
    python3-numpy \
"
