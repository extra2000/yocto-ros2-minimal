BBCLASSEXTEND:append = " nativesdk"

ROS_BRANCH = "nobranch=1"
